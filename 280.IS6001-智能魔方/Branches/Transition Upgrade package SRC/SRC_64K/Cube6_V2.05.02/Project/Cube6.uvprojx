# Keil uVision project Cube6.uvprojx, settings and files
target STM32L151 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cube6_A_V9999 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32L1XX_MD,STM32L151
  c include: ..\Core;..\Lib_code\SysLib\inc;..\Lib_code\SysHard\inc;..\Lib_code\SysPower;..\Lib_code\App;..\User\Driver\USART1;..\User\Driver\ShakeMotor;..\User\Driver\IIC;..\User\MotionSensor;..\Lib_code\SysHard
  memory RVCT4: ROM 0x8000800 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Startup
    ../Core/: system_stm32l1xx.c
    ../Core/startup/: startup_stm32l1xx_md.s
  group SysLib
    ../Lib_code/SysLib/: BestFuLib.c CMDProcess.c Command.c CRC.c Delay.c EEPROM.c FaultManage.c Fifo.c FlashAttr.c LinkScanFifo.c Linksimplest.c Linksrc.c LinkWRDC.c MsgPackage.c Object.c Scene&Group.c Sign433.c Sign433Attr.c SysExeAttr.c SysTestAttr.c Thread.c UnitShare_Attr.c Updata.c Upload.c UserData.c UserDataDownload.c
  group SysHard
    ../Lib_code/SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c FlashSizeFlag.c
    ../Lib_code/SysPower/: ADC.c Battery.c BatteryExeAttr.c LowPower.c
  group APP
    ../Lib_code/App/: main.c UnitCfg.c
  group Drive
    ../User/MotionSensor/: MPU6050.c
    ../User/Driver/ShakeMotor/: ShakeMotor.c
    ../User/Driver/IIC/: IIC.c
  group Unit
    ../User/MotionSensor/: Cube6.c
  group Attr
    ../User/MotionSensor/: Cube6ExeAttr.c
  group Reame
    ../: Readme.txt
